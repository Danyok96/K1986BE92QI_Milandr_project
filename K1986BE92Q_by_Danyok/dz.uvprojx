# Keil uVision project dz.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dz +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\config;..\MDR32F9Qx_StdPeriph_Driver\inc;..\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;..\MDR32F9Qx_StdPeriph_Driver\src;..\MDR32F9Qx_StdPeriph_Driver\src\USB_Library;..\..\K1986BE92Q;.\RTE;..\LCD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ../: main.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h stdint.h
    ../CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ../CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group StdPeriph
    ../MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_lib.h MDR32F9Qx_port.h MDR32F9Qx_rst_clk.h MDR32F9Qx_timer.h MDR32F9Qx_uart.h
    ../MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c
  group LCD
    ../LCD/: Font_6x8.c font_defs.h lcd.c lcd.h systick.c systick.h text.c text.h types.h
software components: CMSIS:CORE 5.0.1
